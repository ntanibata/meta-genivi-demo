SRC_URI_append = "\
    file://0002-configure.ac-apply-wayland-ivi-extension-v1.4.93-or-.patch \
    file://0003-protocol-weston-1.9.0-wayland-ivi-extension-1.4.93.patch \
    file://0004-controller-provisional-fix-to-ilm-input-method.patch \
    file://0005-gdp-hmi-background-supports-dual-display.patch \
"
